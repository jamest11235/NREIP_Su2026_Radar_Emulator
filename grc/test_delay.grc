options:
  parameters:
    author: jtang
    generate_options: qt_gui
    id: test_delay
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: PRI
  id: variable_qtgui_range
  parameters:
    label: Pulse Repetition Interval
    start: '1e-6'
    step: '1e-6'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    label: Relative Delay
    rangeType: int
    start: '0'
    step: int(PRI * samp_rate / 100)
    stop: int(PRI * samp_rate)
    value: '200'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate * PRI)
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '20000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samp_rate * PRI)
    srate: samp_rate
    type: complex
    ymax: '0.2'
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_delay_0, '0', blocks_tag_debug_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
