options:
  parameters:
    author: jtang
    generate_options: qt_gui
    id: lfm_source_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: PRI
  id: variable_qtgui_range
  parameters:
    label: Pulse Repetition Interval
    start: '1e-6'
    step: '1e-6'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.02'
    stop: '1.01'
    value: '1.0'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: 1e3
    step: '1'
    stop: 5e6
    value: 400e3
    widget: counter
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    label: Relative Delay
    rangeType: int
    start: '0'
    step: '50'
    stop: int(3 * PRI * samp_rate)
    value: '200'
    widget: counter
  states: {}
- name: duty_cycle
  id: variable_qtgui_range
  parameters:
    label: Duty Cycle
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
    widget: counter
  states: {}
- name: filter_energy
  id: variable
  parameters:
    value: np.sum(np.abs(raw_filter)**2)
  states: {}
- name: measured_delay
  id: variable
  parameters:
    value: 2.0e9
  states: {}
- name: ramp_rate
  id: variable
  parameters:
    value: bandwidth / (PRI * duty_cycle)
  states: {}
- name: raw_filter
  id: variable
  parameters:
    value: np.exp(-ramp_rate*np.pi*(t_signal[:samples_per_pulse]**2)*1.j)[::-1]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samples_per_pri
  id: variable
  parameters:
    value: int(PRI * samp_rate)
  states: {}
- name: samples_per_pulse
  id: variable
  parameters:
    value: int(PRI * samp_rate * duty_cycle)
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 2.0e9
  states: {}
- name: t_signal
  id: variable
  parameters:
    value: np.arange(samples_per_pri) / samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: int(PRI * samp_rate * 0.5)
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate)
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Embedded Python Block

          Parameters:
              delay (int)
              samples_per_pri (int)

          Message Input:
              meas : PMT pair, second value is an integer

          Message Output:
              dly : PMT long
          """

          def __init__(self, delay=0, samples_per_pri=1024):
              gr.basic_block.__init__(
                  self,
                  name="Delay Calculator",
                  in_sig=None,
                  out_sig=None,
              )

              self.delay = int(delay)
              self.samples_per_pri = int(samples_per_pri)

              # Internal delay state
              self.dly = 0

              # Message ports
              self.message_port_register_in(pmt.intern("meas"))
              self.set_msg_handler(pmt.intern("meas"), self.handle_meas)

              self.message_port_register_out(pmt.intern("dly"))

          def handle_meas(self, msg):
              try:
                  # Expecting a PMT pair (cons cell)
                  meas = int(pmt.to_long(pmt.cdr(msg)))

                  self.dly = (
                      self.dly
                      + self.delay
                      - meas
                      + self.samples_per_pri
                  ) % self.samples_per_pri

                  # Publish updated delay as PMT long
                  self.message_port_pub(
                      pmt.intern("dly"),
                      pmt.from_long(self.dly)
                  )

              except Exception as e:
                  print("Delay Calculator error:", e)

          def general_work(self, input_items, output_items):
              # Message-only block
              return 0
    delay: delay
    samples_per_pri: samples_per_pri
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: raw_filter / filter_energy
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lfmTools_LFM_On_Trigger_0_1
  id: lfmTools_LFM_On_Trigger
  parameters:
    amplitude: amplitude
    bandwidth: bandwidth
    key: RUT
    pulse_width: PRI * duty_cycle
    samp_rate: samp_rate
  states: {}
- name: lfmTools_LFM_Source_0
  id: lfmTools_LFM_Source
  parameters:
    amplitude: amplitude
    bandwidth: bandwidth
    duty_cycle: duty_cycle
    pri: PRI
    samp_rate: samp_rate
  states: {}
- name: lfmTools_peak_cancel_0
  id: lfmTools_peak_cancel
  parameters:
    bandwidth: bandwidth
    key: RUT
    pulse_width: duty_cycle * PRI
    samp_rate: samp_rate
  states: {}
- name: lfmTools_peak_detector_0
  id: lfmTools_peak_detector
  parameters:
    key: RUT
    lookahead: int(PRI * samp_rate * 0.5)
    thres: '0.01'
  states: {}
- name: lfmTools_peak_detector_0_1
  id: lfmTools_peak_detector
  parameters:
    key: Target
    lookahead: int(PRI * samp_rate * 0.5)
    thres: '0.01'
  states: {}
- name: lfmTools_peak_file_sink_0
  id: lfmTools_peak_file_sink
  parameters:
    file: delay.txt
    rx: Target
    tx: RUT
  states: {}
- name: lfmTools_reset_tagger_0
  id: lfmTools_reset_tagger
  parameters:
    wait: int(samp_rate  * 0.1)
  states: {}
- name: lfmTools_tag_advance_0
  id: lfmTools_tag_advance
  parameters:
    advance_samples: int(PRI * duty_cycle * samp_rate)
  states: {}
- name: lfmTools_tag_delay_0
  id: lfmTools_tag_delay
  parameters:
    delay_samples: int(PRI * duty_cycle * samp_rate)
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5, 0, 1, 1
    name: '"Received Signal"'
    size: int(samp_rate * PRI)
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4, 0, 1, 1
    name: '"RUT RX"'
    size: int(samp_rate * PRI)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: int(samples_per_pri)
    srate: samp_rate
    type: float
    ymax: '0.2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samples_per_pri)
    srate: samp_rate
    type: float
    ymax: '0.2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samples_per_pri)
    srate: samp_rate
    type: float
    ymax: '0.2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: int(samples_per_pri)
    srate: samp_rate
    type: float
    ymax: '0.2'
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: start_freq
    clock_source0: internal
    dev_addr: addr=192.168.110.2
    gain0: '10'
    samp_rate: samp_rate
    stream_chans: '1'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: start_freq
    clock_source0: external
    dev_addr: addr=192.168.10.5
    gain0: '10'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: start_freq
    clock_source0: external
    dev_addr: addr=192.168.10.5
    gain0: '10'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: start_freq
    clock_source0: internal
    dev_addr: addr=192.168.110.2
    gain0: '10'
    samp_rate: samp_rate
    stream_chans: '0'
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: reset
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: dly
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: reset
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: dly
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', lfmTools_peak_detector_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_1_0_0_0, '1']
- [blocks_skiphead_0, '0', lfmTools_peak_file_sink_0, '0']
- [epy_block_0, dly, virtual_sink_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [lfmTools_LFM_On_Trigger_0_1, '0', blocks_delay_0, '0']
- [lfmTools_LFM_Source_0, '0', uhd_usrp_sink_0, '0']
- [lfmTools_peak_cancel_0, '0', lfmTools_tag_delay_0, '0']
- [lfmTools_peak_detector_0, '0', lfmTools_LFM_On_Trigger_0_1, '0']
- [lfmTools_peak_detector_0, '0', lfmTools_tag_advance_0, '0']
- [lfmTools_peak_detector_0, '0', qtgui_time_sink_x_1_0, '0']
- [lfmTools_peak_detector_0_1, '0', blocks_skiphead_0, '0']
- [lfmTools_peak_detector_0_1, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [lfmTools_peak_file_sink_0, delay, blocks_message_debug_0, print]
- [lfmTools_peak_file_sink_0, delay, epy_block_0, meas]
- [lfmTools_peak_file_sink_0, delay, virtual_sink_0, '0']
- [lfmTools_reset_tagger_0, '0', fft_filter_xxx_0, '0']
- [lfmTools_tag_advance_0, '0', lfmTools_peak_cancel_0, '0']
- [lfmTools_tag_delay_0, '0', blocks_delay_1, '0']
- [lfmTools_tag_delay_0, '0', lfmTools_peak_detector_0_1, '0']
- [lfmTools_tag_delay_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [uhd_usrp_source_0, '0', lfmTools_reset_tagger_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [virtual_source_0, '0', lfmTools_reset_tagger_0, reset]
- [virtual_source_1, '0', blocks_delay_0, dly]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
