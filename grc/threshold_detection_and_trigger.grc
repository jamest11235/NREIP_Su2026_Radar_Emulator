options:
  parameters:
    generate_options: qt_gui
    id: new
    output_language: python
    title: LFM_Generator
  states: {}

blocks:
- name: PRI
  id: variable_qtgui_range
  parameters:
    label: Pulse Repetition Interval
    start: '1e-6'
    step: '1e-6'
    stop: '1e-3'
    value: '5e-4'
    widget: counter
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.02'
    stop: '1.01'
    value: '0.5'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: 1e3
    step: '1'
    stop: 5e6
    value: 200e3
    widget: counter
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 3e9
  states: {}
- name: duty_cycle
  id: variable_qtgui_range
  parameters:
    label: Duty Cycle
    start: '0'
    step: '0.02'
    stop: '1.01'
    value: '0.25'
  states: {}
- name: filter_energy
  id: variable
  parameters:
    value: np.sum(np.abs(raw_filter)**2)
  states: {}
- name: ramp_rate
  id: variable
  parameters:
    value: bandwidth / (PRI * duty_cycle)
  states: {}
- name: raw_filter
  id: variable
  parameters:
    value: np.exp(-ramp_rate*np.pi*(t_signal[:samples_per_pulse]**2)*1.j)[::-1]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samples_per_pri
  id: variable
  parameters:
    value: int(PRI * samp_rate)
  states: {}
- name: samples_per_pulse
  id: variable
  parameters:
    value: int(PRI * duty_cycle * samp_rate)
  states: {}
- name: sdr_lo
  id: variable
  parameters:
    value: center_freq-bandwidth*0.5
  states: {}
- name: t_signal
  id: variable
  parameters:
    value: __import__("numpy").arange(samples_per_pri) / samp_rate
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.001'
    max_gain: '1.0'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1/amplitude
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: 'int(duty_cycle * PRI * samp_rate) '
    threshold_factor_fall: '20'
    threshold_factor_rise: '20'
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: raw_filter / filter_energy
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lfmTools_LFM_On_Trigger_0
  id: lfmTools_LFM_On_Trigger
  parameters:
    amplitude: amplitude
    bandwidth: bandwidth
    pulse_width: PRI*duty_cycle
    samp_rate: samp_rate
  states: {}
- name: lfmTools_LFM_Source_0
  id: lfmTools_LFM_Source
  parameters:
    amplitude: amplitude
    bandwidth: bandwidth
    duty_cycle: duty_cycle
    pri: PRI
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: LFM_I
    label2: LFM_Q
    name: '"TX Signal"'
    size: samples_per_pri * 5
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: LFM_I
    label2: LFM_Q
    name: '"RX Signal"'
    size: samples_per_pri * 5
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: LFM_I
    label2: LFM_Q
    name: '"Matched Output"'
    nconnections: '2'
    size: samples_per_pri * 5
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: sdr_lo
    gain0: '15'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: sdr_lo
    gain0: '15'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0, '0', lfmTools_LFM_On_Trigger_0, '0']
- [blocks_complex_to_magphase_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_null_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_peak_detector_xb_0, '0', blocks_char_to_float_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_magphase_0, '0']
- [lfmTools_LFM_On_Trigger_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [lfmTools_LFM_Source_0, '0', qtgui_time_sink_x_0, '0']
- [lfmTools_LFM_Source_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
